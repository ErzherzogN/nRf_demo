# Keil uVision project ble_app_lbs.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_app_lbs +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD  SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\Libs\ble;..\Libs\ble\ble_debug_assert_handler;..\Libs\ble\ble_error_log;..\Libs\ble\common;..\Libs\device;..\Libs\drivers_nrf\ble_flash;..\Libs\drivers_nrf\hal;..\Libs\drivers_nrf\pstorage;..\Libs\drivers_nrf\sdio;..\Libs\drivers_nrf\clock;..\Libs\libraries\button;..\Libs\libraries\crc16;..\Libs\libraries\gpiote;..\Libs\libraries\timer;..\Libs\libraries\scheduler;..\Libs\libraries\util;..\Libs\softdevice\common\softdevice_handler;..\Libs\softdevice\common;..\Libs\softdevice\s110\headers;..\Libs\toolchain;..\Libs\drivers_nrf\pstorage\config
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../Libs/toolchain/arm/: arm_startup_nrf51.s
    ../Libs/toolchain/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../: ble_lbs.c
    ../Libs/ble/common/: ble_srv_common.c
  group Libraries
    ../Libs/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../Libs/ble/ble_error_log/: ble_error_log.c
    ../Libs/ble/common/: ble_advdata.c ble_conn_params.c
    ../Libs/libraries/button/: app_button.c
    ../Libs/libraries/scheduler/: app_scheduler.c
    ../Libs/libraries/crc16/: crc16.c
    ../Libs/libraries/timer/: app_timer.c app_timer_appsh.c
    ../Libs/libraries/gpiote/: app_gpiote.c
    ../Libs/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../Libs/drivers_nrf/pstorage/: pstorage.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_lbs +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
